Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-04-25T10:38:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 25 10:38:57 2019 * Host: SarahSams-HP * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{8EAB50EF-4670-419F-B2C2-C251A6E79B90}\ifc * Database version: 5507 * Database creation date: Thu Apr 25 10:38:55 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 25 10:38:56 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 25 10:38:56 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: Battery Pack Brushed Stainless Steel, Duten_WtrSplyFitngsForWshBsnsAndTrghs_R310:Battery Pack Brushed Stainless Steel:261141
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel
Type - Constraints - Default Elevation: 1200 mm
Type - General - Author: Diane Butterworth Ltd; ManufacturerName: Duten; ManufacturerURL: http://www.duten.fr/; NBSDescription: Taps and water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: https://www.duten.fr/produits/robinetterie/robinet-electronique-r310; Revision: n/a; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: Pr-Products v1.10
Type - Identity Data - Assembly Code: C1030210; Assembly Description: Bath & Toilet Accessories - Commercial; Cost: 0; Description: Battery Pack Brushed Stainless Steel; Keynote: Pr_40_20_87_98; Manufacturer: Duten; Model: R310-S_BAT; Type Comments: Battery Pack Brushed Stainless Steel; Type Name: Battery Pack Brushed Stainless Steel; URL: http://www.duten.fr/
Type - Materials and Finishes - SensorFinish: Duten_Plastic_Black; TapFinish: Duten_Metal_BrushedStainlessSteel
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Moveable; BarCode: n/a; CodePerformance: WRAS Approved. ASME A112.18.1-2011/CSA B125.1-11; Color: Defined by Finish; Constituents: Stainless Steel Stem, Touchless Sensor, Concealed Battery Power; DurationUnit: Years; ExpectedLife: 10; Family Name: Duten_WtrSplyFitngsForWshBsnsAndTrghs_R310; Features: Electronic deck mounted tap for pre-mixed or cold water. Solid brass body, with infrared motion detection.; Finish: Brushed, Polished or Matte Black Stainless Steel Available; Grade: n/a; InstallationDate: 1900-12-31T23:59:59; Material: Stainless Steel; ModelNumber: R310-S_BAT; ModelReference: Battery Pack Brushed Stainless Steel; Name: WaterSupplyFittingsForWashBasinsAndTroughs_R380-MP_Duten; ReplacementCost: 0; SerialNumber: n/a; Shape: Cylindrical; Size: (H) 170mm x (L) 150mm x (W) 45mm; SustainabilityPerformance: n/a; TagNumber: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: contact@duten.fr; WarrantyDurationParts: contact@duten.fr; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: 10; WarrantyGuarantorParts: 10; WarrantyStartDate: 1900-12-31T23:59:59
Type - Plumbing - CW Connection: yes; FlowRate: 3L/min; HW Connection: yes; Vent Connection: no; Waste Connection: no; WaterSupplyTemperatureMaximum: 70 °C
Pset_ManufacturerTypeInformation - ModelReference: Battery Pack Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
Constraints - Elevation: 900 mm; Host: Casework_Counter_Top : 625mm_Depth; Level: Level: Level 0
Dimensions - Area: 0.0195028 m2; Volume: 0.000316502 m3
Identity Data - Mark: 2
Mechanical - System Classification: Other,Controls
Other - Family: Duten_WtrSplyFitngsForWshBsnsAndTrghs_R310: Battery Pack Brushed Stainless Steel; Family and Type: Duten_WtrSplyFitngsForWshBsnsAndTrghs_R310: Battery Pack Brushed Stainless Steel; Schedule Level: Level: Level 0; Type: Duten_WtrSplyFitngsForWshBsnsAndTrghs_R310: Battery Pack Brushed Stainless Steel; Type Id: Duten_WtrSplyFitngsForWshBsnsAndTrghs_R310: Battery Pack Brushed Stainless Steel
Phasing - Phase Created: New Construction

# IfcFurnishingElement: 625mm_Depth, Casework_Counter_Top:625mm_Depth:260174
In: Level 0
Type - ElementType: 625mm_Depth; Material: Laminate - Marble
Type - Dimensions - Counter Thickness: 40 mm; Depth: 625 mm; Height: 900 mm
Type - Graphics - Vis - Worktop Upstand: yes
Type - Identity Data - Keynote: N10; Type Name: 625mm_Depth
Type - Materials and Finishes - Counter Top Material: Laminate - Marble
Type - Other - Category: Casework; Family Name: Casework_Counter_Top
Constraints - Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.12914 m2; Length: 1437.79 mm; Volume: 0.0387274 m3
Other - Family: Casework_Counter_Top: 625mm_Depth; Family and Type: Casework_Counter_Top: 625mm_Depth; Type: Casework_Counter_Top: 625mm_Depth; Type Id: Casework_Counter_Top: 625mm_Depth
Phasing - Phase Created: New Construction
